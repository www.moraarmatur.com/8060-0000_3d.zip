Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: X:\Work\Ostnor\Projekt\Projekt 2012\CAD-objekt_2012-05-10, David\80600000\AutoCAD Architecture\80600000.ifc
Time: 2012-05-30T17:57:08
Author: Jonas Kylander
Organization: FMM
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 80600000
LongName: 80600000
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 80600000
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 80600000, BUILDINGELEMENTPROXY(1)
In: 80600000
Description: FMM Basin Mixer 9000E II, Chrome
